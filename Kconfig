## Kconfig
```kconfig
config PROC_INTEGRITY
	tristate "Simple process integrity checker"
	default y
	help
	  Simple process integrity checker
```
